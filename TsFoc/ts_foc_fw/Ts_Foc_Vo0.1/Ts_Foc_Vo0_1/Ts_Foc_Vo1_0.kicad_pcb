# Repository tangsangsimida/FOC_L

File README.md:

**目录结构概述**:  
该路径包含 6 个目录和 9 个文件，主要涉及 FOC（Field-Oriented Control，磁场定向控制）算法相关的项目、课程资料、代码库和文档。

---

### 目录结构详情

#### 目录 (6 个)
1. **参考项目**: 包含与 FOC 相关的参考项目或示例代码。
2. **CawFOC**: 一个 FOC 算法的实现项目或代码库。
3. **DengFOC**: 一个 FOC 算法的实现项目或代码库。
4. **odriver**: 与电机驱动相关的项目或工具。
5. **ts_foc_fw**: 与 FOC 固件（Firmware）相关的项目。
6. **Tsfoc_Soft_V0_1**: 一个 FOC 软件的早期版本（V0.1）。

#### 文件 (9 个)
1. **【手把手教学FOC算法】 课程例程包.zip**: 包含 FOC 算法的教学课程和示例代码的压缩包。
2. **bldc-master.zip**: 与 BLDC（无刷直流电机）相关的代码库或项目压缩包。
3. **eg2133_34对比.md**: 关于 eg2133 和 eg2134 芯片对比的 Markdown 文档。
4. **gitpush.sh**: 用于自动化 Git 推送操作的 Shell 脚本。
5. **LICENSE**: 项目的许可证文件，说明代码的使用权限和限制。
6. **README.md**: 项目的说明文档，包含项目简介、使用方法等信息。
7. **SCH_G431永磁双驱_2024-10-08.json**: 与永磁双驱电机相关的原理图设计文件（JSON 格式）。
8. **simple_focproject.zip**: 包含一个简单的 FOC 项目的压缩包。
9. **tree.txt**: 当前文件，记录了目录结构的树形图。

---

### 备注
- 该路径内容围绕 FOC 算法及其相关应用，包括电机控制、固件开发、课程资料等。
- 文件类型包括压缩包（`.zip`）、Markdown 文档（`.md`）、Shell 脚本（`.sh`）、JSON 文件等，表明项目内容多样化。

## KiCad design TsFoc/ts_foc_fw/Ts_Foc_Vo0.1/Ts_Foc_Vo0_1/Ts_Foc_Vo1_0.kicad_pcb

File TsFoc/ts_foc_fw/Ts_Foc_Vo0.1/Readme.md:

# Ts_Foc_Vo1_0

##### 说明

1. 基于先前单路Ts_Foc驱动器改进带mcu控制器驱动器
2. 支持CANHD、USB、USART通讯方式
3. 支持电流检测
4. 支持双路电机控制
5. 布局参考Odriver3.6
6. PCB完全使用kicad8.7设计

Notes on the sheet:
2.布局参考odriver3.6开源版本
1.本项目根据Ts_Foc单电机版本迭代
Readme:

Parts:
LED2: GREEN; LED_0603
LED3: LED_RGB; LED-RGB-SMD_4P
R9, R10, R12, R13, R14: 10k; Res_0402
SW1: BOTTOM

Connections:
3V3: LED3.2 (COM+), R9.2, R10.1; also elsewhere on the board
BOTTON: R10.2, SW1.2; also elsewhere on the board
GND: SW1.1; also elsewhere on the board
LED: LED2.1 (K); also elsewhere on the board
unnamed: LED2.2 (A), R9.1
unnamed: LED3.3 (B-), R14.2
unnamed: LED3.4 (G-), R13.2
unnamed: LED3.1 (R-), R12.1
RGB-B: R14.1; also elsewhere on the board
RGB-G: R13.1; also elsewhere on the board
RGB-R: R12.2; also elsewhere on the board

Notes on the sheet:
用户按键
用户LED
Mcu：
RGB灯

Parts:
D2: LMBR240ET1G; LMBR240ET1G_SOD323HE
LED1: GREEN; LED_0603
Q1: JSM2301S; JSM2301S_SOT-23
R4, R5: 10k; Res_0402

Connections:
3V3: R4.2; also elsewhere on the board
5V: D2.1 (C), Q1.2 (S); also elsewhere on the board
5V_DC: D2.2 (A), Q1.1 (G), R5.1; also elsewhere on the board
5V_USB: Q1.3 (D)
GND: LED1.1 (K), R5.2; also elsewhere on the board
unnamed: LED1.2 (A), R4.1

Notes on the sheet:
电源指示灯
强弱电源切换

Parts:
CN1, CN2: MR30PW-M30.G.Y; MR30PW-M30-G-Y
CN3, CN4: GH1.25-2P_LT; GH1.25_1X2
CN5: XT30PW-M
CN6, CN7, CN8, CN9, CN10: GH1.25-4P; GH1.25_CONN-SMD_4P-P1.25
CN11, CN12: GH1.25-5PLT; GH1.25_CONN-SMD_5P-P1.25
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
TV1: SMAJ36CA; SMA_L4.4

Connections:
3V3: CN6.3, CN7.3, CN8.3, CN9.2, CN10.2, CN11.2, CN12.2, J1.4; also elsewhere on the board
FDCAN1-H: CN3.1; also elsewhere on the board
FDCAN1-L: CN3.2; also elsewhere on the board
FDCAN2-H: CN4.1; also elsewhere on the board
FDCAN2-L: CN4.2; also elsewhere on the board
GND: CN1.4, CN1.5, CN2.4, CN2.5, CN3.3, CN3.4, CN4.3, CN4.4, CN5.1 (-), CN5.3, CN5.4, CN6.4, CN6.5, CN6.6, CN7.4, CN7.5, CN7.6, CN8.4, CN8.5, CN8.6, CN9.1, CN9.5, CN9.6, CN10.1, CN10.5, CN10.6, CN11.1, CN11.6, CN11.7, CN12.1, CN12.6, CN12.7, J1.2, TV1.1 (K); also elsewhere on the board
I2C1-SCL: CN9.4; also elsewhere on the board
I2C1-SDA: CN9.3; also elsewhere on the board
I2C2-SCL: CN10.4; also elsewhere on the board
I2C2-SDA: CN10.3; also elsewhere on the board
M0_OUT1_P: CN1.3; also elsewhere on the board
M0_OUT2_P: CN1.2; also elsewhere on the board
M0_OUT3: CN1.1; also elsewhere on the board
M1_OUT1_P: CN2.3; also elsewhere on the board
M1_OUT2_P: CN2.2; also elsewhere on the board
M1_OUT3: CN2.1; also elsewhere on the board
SPI1-MISO: CN11.4; also elsewhere on the board
SPI1-MOSI: CN11.3; also elsewhere on the board
SPI1-SCK: CN11.5; also elsewhere on the board
SPI2-MISO: CN12.4; also elsewhere on the board
SPI2-MOSI: CN12.3; also elsewhere on the board
SPI2-SCK: CN12.5; also elsewhere on the board
SWCLK: J1.3; also elsewhere on the board
SWDIO: J1.1; also elsewhere on the board
UART1-RX: CN6.2; also elsewhere on the board
UART1-TX: CN6.1; also elsewhere on the board
UART2-RX: CN7.2; also elsewhere on the board
UART2-TX: CN7.1; also elsewhere on the board
UART3-RX: CN8.2; also elsewhere on the board
UART3-TX: CN8.1; also elsewhere on the board
VCC: CN5.2 (+), TV1.2 (A); also elsewhere on the board

Notes on the sheet:
CAN
PowerIn
电机接口
IIC-AS5600X2
Connector:
SPI预留接口
USART
SWD

Notes on the sheet:
Drive:

Parts:
C11, C12: 2.2uf; CAP_0402
C13, C14: 100nf; CAP_0402
C15: 10uf; CAP_0402
C16, C17, C18: 22pf; CAP_0402
R6, R7: 10k; Res_0402
R8, R11: 1M; Res_0402
SW2: BOTTOM
U3: STM32F407VET6; STM32_F407_VET6_LQFP-100
X1: 25Mhz; XTAL-SMD

Connections:
3V3: C13.2, C14.1, C15.1, R11.2, U3.6 (VBAT), U3.11 (VDD), U3.19 (VDD), U3.21 (VREF+), U3.22 (VDDA), U3.28 (VDD), U3.50 (VDD), U3.75 (VDD), U3.100 (VDD); also elsewhere on the board
ADC1-IN0: U3.23 (PA0-WKUP(PA0)); also elsewhere on the board
ADC1-IN1: U3.24 (PA1); also elsewhere on the board
ADC1-IN2: U3.25 (PA2); also elsewhere on the board
ADC1-IN3: U3.26 (PA3); also elsewhere on the board
BOTTON: U3.8 (PC14-OSC32_IN(PC14)); also elsewhere on the board
FDCAN1-RX: U3.81 (PD0); also elsewhere on the board
FDCAN1-TX: U3.82 (PD1); also elsewhere on the board
FDCAN2-RX: U3.91 (PB5); also elsewhere on the board
FDCAN2-TX: U3.92 (PB6); also elsewhere on the board
GND: C11.1, C12.1, C13.1, C14.2, C15.2, C16.1, C17.1, C18.1, R6.1, R7.1, SW2.2, U3.10 (VSS), U3.20 (VSSA), U3.27 (VSS), U3.74 (VSS), U3.99 (VSS); also elsewhere on the board
I2C1-SCL: U3.95 (PB8); also elsewhere on the board
I2C1-SDA: U3.96 (PB9); also elsewhere on the board
I2C2-SCL: U3.47 (PB10); also elsewhere on the board
I2C2-SDA: U3.48 (PB11); also elsewhere on the board
LED: U3.7 (PC13); also elsewhere on the board
M0-IN1: U3.62 (PD15); also elsewhere on the board
M0-IN2: U3.63 (PC6); also elsewhere on the board
M0-IN3: U3.64 (PC7); also elsewhere on the board
M1-IN1: U3.59 (PD12); also elsewhere on the board
M1-IN2: U3.60 (PD13); also elsewhere on the board
M1-IN3: U3.61 (PD14); also elsewhere on the board
NRST: C18.2, R11.1, SW2.1, U3.14 (NRST)
unnamed: R7.2, U3.94 (BOOT0)
unnamed: R6.2, U3.37 (PB2-BOOT1(PB2))
unnamed: C11.2, U3.49 (VCAP_1)
unnamed: C12.2, U3.73 (VCAP_2)
PA4: U3.29 (PA4)
PA8: U3.67 (PA8)
PA15: U3.77 (PA15(JTDI))
PB0: U3.35 (PB0)
PB1: U3.36 (PB1)
PB3: U3.89 (PB3(JTDOTRACESWO))
PB4: U3.90 (PB4(NJTRST))
PB7: U3.93 (PB7)
PB12: U3.51 (PB12)
PC0: U3.15 (PC0)
PC1: U3.16 (PC1)
PC2: U3.17 (PC2)
PC3: U3.18 (PC3)
PC4: U3.33 (PC4)
PC5: U3.34 (PC5)
PC8: U3.65 (PC8)
PC9: U3.66 (PC9)
PC10: U3.78 (PC10)
PC11: U3.79 (PC11)
PC12: U3.80 (PC12)
PC15: U3.9 (PC15-OSC32_OUT(PC15))
PD2: U3.83 (PD2)
PD3: U3.84 (PD3)
PD4: U3.85 (PD4)
PD7: U3.88 (PD7)
PD10: U3.57 (PD10)
PD11: U3.58 (PD11)
PE0: U3.97 (PE0)
PE1: U3.98 (PE1)
PE2: U3.1 (PE2)
PE3: U3.2 (PE3)
PE4: U3.3 (PE4)
PE5: U3.4 (PE5)
PE6: U3.5 (PE6)
PE7: U3.38 (PE7)
PE8: U3.39 (PE8)
PE10: U3.41 (PE10)
PE12: U3.43 (PE12)
PE14: U3.45 (PE14)
PE15: U3.46 (PE15)
PH0-OSC_IN(PH0): C16.2, R8.1, U3.12 (PH0-OSC_IN(PH0)), X1.2 (OSC2)
PH1-OSC_OUT(PH1): C17.2, R8.2, U3.13 (PH1-OSC_OUT(PH1)), X1.1 (OSC1)
RGB-B: U3.44 (PE13); also elsewhere on the board
RGB-G: U3.42 (PE11); also elsewhere on the board
RGB-R: U3.40 (PE9); also elsewhere on the board
SPI1-MISO: U3.31 (PA6); also elsewhere on the board
SPI1-MOSI: U3.32 (PA7); also elsewhere on the board
SPI1-SCK: U3.30 (PA5); also elsewhere on the board
SPI2-MISO: U3.53 (PB14); also elsewhere on the board
SPI2-MOSI: U3.54 (PB15); also elsewhere on the board
SPI2-SCK: U3.52 (PB13); also elsewhere on the board
SWCLK: U3.76 (PA14(JTCK-SWCLK)); also elsewhere on the board
SWDIO: U3.72 (PA13(JTMS-SWDIO)); also elsewhere on the board
UART1-RX: U3.69 (PA10); also elsewhere on the board
UART1-TX: U3.68 (PA9); also elsewhere on the board
UART2-RX: U3.87 (PD6); also elsewhere on the board
UART2-TX: U3.86 (PD5); also elsewhere on the board
UART3-RX: U3.56 (PD9); also elsewhere on the board
UART3-TX: U3.55 (PD8); also elsewhere on the board
USB-DM: U3.70 (PA11); also elsewhere on the board
USB-DP: U3.71 (PA12); also elsewhere on the board

Notes on the sheet:
外部高速晶振
复位电路

Parts:
C1: 10nf; CAP_0402
C2: 470pf; CAP_0402
C3, C6: 10uf; CAP_0402
C4, C5: 100nf; CAP_0402
D1: B340A; B340A_SMA
L1: 15uh; IND-SMD
R1: 10r; Res_0402
R2: 10k; Res_0402
R3: 3.24k; Res_0402
U1: TPS5430DDAR; TPS5430DDAR_ESOP-8

Connections:
5V_DC: C2.2, C3.1, C4.1, L1.1, R2.2; also elsewhere on the board
GND: C3.2, C4.2, C5.1, C6.1, D1.2 (A), R1.1, R3.1, U1.6 (GND), U1.9 (PowerPAD); also elsewhere on the board
unnamed: C2.1, R1.2
unnamed: C1.2, U1.1 (BOOT)
PH: C1.1, D1.1 (K), L1.2, U1.8 (PH)
VCC: C5.2, C6.2, U1.7 (VIN); also elsewhere on the board
VSNS: R2.1, R3.2, U1.4 (VSENSE)

Notes on the sheet:
12V-5V DC

Parts:
C7, C10: 100nf; CAP_0402
C8, C9: 10uf; CAP_0402
U2: AMS1117-3.3V; AMS1117_SOT-89

Connections:
3V3: C9.2, C10.2, U2.2 (VOUT); also elsewhere on the board
5V_DC: C7.1, C8.1, U2.3 (VIN); also elsewhere on the board
GND: C7.2, C8.2, C9.1, C10.1, U2.1 (ADJ/GND); also elsewhere on the board

Notes on the sheet:
5V-3V3

Schematic: USB.kicad_sch

Parts:
R33, R34: 5.1K; Res_0402
R35, R36: 22r; Res_0402
USB1: TYPE-C-16P; USB-C-16P-SMD

Connections:
5V-USB: USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)
DM: R35.2, USB1.A7 (D-), USB1.B7 (D-)
DP: R36.2, USB1.A6 (D+), USB1.B6 (D+)
GND: R33.1, R34.1, USB1.1 (SHELL), USB1.2 (SHELL), USB1.3 (SHELL), USB1.4 (SHELL), USB1.A1B12 (GND), USB1.B1A12 (GND); also elsewhere on the board
unnamed: R34.2, USB1.A8 (SBU1)
unnamed: R33.2, USB1.B8 (SBU2)
USB-DM: R35.1; also elsewhere on the board
USB-DP: R36.1; also elsewhere on the board

Notes on the sheet:
USB_TYPE-C

Schematic: CAN.kicad_sch

Parts:
R31, R32: 120r; Res_0402
U10, U11: SIT1050TK; SIT1050TK_TDFN-8

Connections:
5V: U10.3 (VCC), U11.3 (VCC); also elsewhere on the board
FDCAN1-H: R31.2, U10.7 (CANH); also elsewhere on the board
FDCAN1-L: R31.1, U10.6 (CANL); also elsewhere on the board
FDCAN1-RX: U10.4 (RXD); also elsewhere on the board
FDCAN1-TX: U10.1 (TXD); also elsewhere on the board
FDCAN2-H: R32.2, U11.7 (CANH); also elsewhere on the board
FDCAN2-L: R32.1, U11.6 (CANL); also elsewhere on the board
FDCAN2-RX: U11.4 (RXD); also elsewhere on the board
FDCAN2-TX: U11.1 (TXD); also elsewhere on the board
GND: U10.2 (GND), U10.8 (S), U10.9 (EP), U11.2 (GND), U11.8 (S), U11.9 (EP); also elsewhere on the board
VCC: U10.5 (Vref), U11.5 (Vref); also elsewhere on the board

Notes on the sheet:
CAN收发器

Schematic: drive1.kicad_sch

Parts:
C19: 1uf; CAP_0402
C20, C21, C22, C23: 100nf; CAP_0402
D3, D4, D5: DSK34; DSK_34_SOD-123
D6, D7, D8, D9, D10, D11: 1N4148W; 1N4148W_SOD-123
Q2, Q3, Q4, Q5, Q6, Q7: RU3089M-C; RU3089M-C_PQFN-8
R15, R16: 10mr; Res_1206
R17, R18, R19, R20, R21, R22: 2.2r; Res_0402
U4: EG2133; EG2133_TSSOP
U5, U6: INA240A2PWR; INA240A2PWR_TSSOP-8

Connections:
3V3: U5.5 (VS), U5.6 (REF2), U6.5 (VS), U6.6 (REF2); also elsewhere on the board
5V: D3.2 (A), D4.2 (A), D5.2 (A); also elsewhere on the board
ADC1-IN0: U5.8 (OUT); also elsewhere on the board
ADC1-IN1: U6.8 (OUT); also elsewhere on the board
GND: C19.1, C20.1, U4.8 (GND), U5.4 (GND), U5.7 (REF1), U6.4 (GND), U6.7 (REF1); also elsewhere on the board
M0-IN1: U4.1 (HIN1), U4.4 (LIN1#); also elsewhere on the board
M0-IN2: U4.2 (HIN2), U4.5 (LIN2#); also elsewhere on the board
M0-IN3: U4.3 (HIN3), U4.6 (LIN3#); also elsewhere on the board
M0_GH1: D6.2 (K), R17.2, U4.19 (HO1)
M0_GH2: D8.2 (K), R19.2, U4.16 (HO2)
M0_GH3: D10.2 (K), R21.2, U4.13 (HO3)
M0_GL1: D7.2 (K), R18.2, U4.11 (LO1)
M0_GL2: D9.2 (K), R20.2, U4.10 (LO2)
M0_GL3: D11.2 (K), R22.2, U4.9 (LO3)
M0_OUT1: C21.1, U4.18 (VS1)
M0_OUT1_P: Q2.1 (S), Q2.2 (S), Q2.3 (S), Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D), Q3.9 (D), R15.1, U5.3 (IN-); also elsewhere on the board
M0_OUT2: C22.1, U4.15 (VS2)
M0_OUT2_P: Q4.1 (S), Q4.2 (S), Q4.3 (S), Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D), Q5.9 (D), R16.1, U6.3 (IN-); also elsewhere on the board
M0_OUT3: C23.1, Q6.1 (S), Q6.2 (S), Q6.3 (S), Q7.5 (D), Q7.6 (D), Q7.7 (D), Q7.8 (D), Q7.9 (D), U4.12 (VS3); also elsewhere on the board
unnamed: C21.2, D3.1 (K), U4.20 (VB1)
unnamed: C22.2, D4.1 (K), U4.17 (VB2)
unnamed: C23.2, D5.1 (K), U4.14 (VB3)
unnamed: D6.1 (A), Q2.4 (G), R17.1
unnamed: D7.1 (A), Q3.4 (G), R18.1
unnamed: D8.1 (A), Q4.4 (G), R19.1
unnamed: D9.1 (A), Q5.4 (G), R20.1
unnamed: D10.1 (A), Q6.4 (G), R21.1
unnamed: D11.1 (A), Q7.4 (G), R22.1
unnamed: C19.2, C20.2, U4.7 (VCC)
unnamed: R15.2, U5.2 (IN+)
unnamed: R16.2, U6.2 (IN+)
PGND: Q3.1 (S), Q3.2 (S), Q3.3 (S), Q5.1 (S), Q5.2 (S), Q5.3 (S), Q7.1 (S), Q7.2 (S), Q7.3 (S); also elsewhere on the board
VCC: Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), Q2.9 (D), Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D), Q4.9 (D), Q6.5 (D), Q6.6 (D), Q6.7 (D), Q6.8 (D), Q6.9 (D); also elsewhere on the board

Notes on the sheet:
电流采样
Motor1
三项全桥逆变
EG2133+自举

Schematic: drive2.kicad_sch

Parts:
C24: 1uf; CAP_0402
C25, C26, C27, C28: 100nf; CAP_0402
D12, D13, D14: DSK34; DSK_34_SOD-123
D15, D16, D17, D18, D19, D20: 1N4148W; 1N4148W_SOD-123
Q8, Q9, Q10, Q11, Q12, Q13: RU3089M-C; RU3089M-C_PQFN-8
R23, R24: 10mr; Res_1206
R25, R26, R27, R28, R29, R30: 2.2r; Res_0402
U7: EG2133; EG2133_TSSOP
U8, U9: INA240A2PWR; INA240A2PWR_TSSOP-8

Connections:
3V3: U8.5 (VS), U8.6 (REF2), U9.5 (VS), U9.6 (REF2); also elsewhere on the board
5V: D12.2 (A), D13.2 (A), D14.2 (A); also elsewhere on the board
ADC1-IN2: U8.8 (OUT); also elsewhere on the board
ADC1-IN3: U9.8 (OUT); also elsewhere on the board
GND: C24.1, C25.1, U7.8 (GND), U8.4 (GND), U8.7 (REF1), U9.4 (GND), U9.7 (REF1); also elsewhere on the board
M1-IN1: U7.1 (HIN1), U7.4 (LIN1#); also elsewhere on the board
M1-IN2: U7.2 (HIN2), U7.5 (LIN2#); also elsewhere on the board
M1-IN3: U7.3 (HIN3), U7.6 (LIN3#); also elsewhere on the board
M1_GH1: D15.2 (K), R25.2, U7.19 (HO1)
M1_GH2: D17.2 (K), R27.2, U7.16 (HO2)
M1_GH3: D19.2 (K), R29.2, U7.13 (HO3)
M1_GL1: D16.2 (K), R26.2, U7.11 (LO1)
M1_GL2: D18.2 (K), R28.2, U7.10 (LO2)
M1_GL3: D20.2 (K), R30.2, U7.9 (LO3)
M1_OUT1: C26.1, U7.18 (VS1)
M1_OUT1_P: Q8.1 (S), Q8.2 (S), Q8.3 (S), Q9.5 (D), Q9.6 (D), Q9.7 (D), Q9.8 (D), Q9.9 (D), R23.1, U8.3 (IN-); also elsewhere on the board
M1_OUT2: C27.1, U7.15 (VS2)
M1_OUT2_P: Q10.1 (S), Q10.2 (S), Q10.3 (S), Q11.5 (D), Q11.6 (D), Q11.7 (D), Q11.8 (D), Q11.9 (D), R24.1, U9.3 (IN-); also elsewhere on the board
M1_OUT3: C28.1, Q12.1 (S), Q12.2 (S), Q12.3 (S), Q13.5 (D), Q13.6 (D), Q13.7 (D), Q13.8 (D), Q13.9 (D), U7.12 (VS3); also elsewhere on the board
unnamed: C26.2, D12.1 (K), U7.20 (VB1)
unnamed: C27.2, D13.1 (K), U7.17 (VB2)
unnamed: C28.2, D14.1 (K), U7.14 (VB3)
unnamed: D15.1 (A), Q8.4 (G), R25.1
unnamed: D16.1 (A), Q9.4 (G), R26.1
unnamed: D17.1 (A), Q10.4 (G), R27.1
unnamed: D18.1 (A), Q11.4 (G), R28.1
unnamed: D19.1 (A), Q12.4 (G), R29.1
unnamed: D20.1 (A), Q13.4 (G), R30.1
unnamed: C24.2, C25.2, U7.7 (VCC)
unnamed: R23.2, U8.2 (IN+)
unnamed: R24.2, U9.2 (IN+)
PGND: Q9.1 (S), Q9.2 (S), Q9.3 (S), Q11.1 (S), Q11.2 (S), Q11.3 (S), Q13.1 (S), Q13.2 (S), Q13.3 (S); also elsewhere on the board
VCC: Q8.5 (D), Q8.6 (D), Q8.7 (D), Q8.8 (D), Q8.9 (D), Q10.5 (D), Q10.6 (D), Q10.7 (D), Q10.8 (D), Q10.9 (D), Q12.5 (D), Q12.6 (D), Q12.7 (D), Q12.8 (D), Q12.9 (D); also elsewhere on the board

Notes on the sheet:
EG2133+自举
电流采样
三项全桥逆变
Motor2

Board: 2 copper layers, 130 parts (0 on the bottom side), 116 nets, no tracks yet.

## KiCad design ts_foc_fw/EG2134_single_motor/EG2134_single_motor_drive/EG2134_single_motor_drive.kicad_pcb

File ts_foc_fw/EG2134_single_motor/EG2134_single_motor_drive/readme.md:

# 修改问题：

1. 修改电流采样引脚未连接问题

# 未验证问题：

1. 降压部分电路芯片问题未验证
2. 

# 剩余问题：

1.

Notes on the sheet:
2. EG2134
1. Power
3. cirrent_sensor
目录：
4. Connection
5. Readme

Parts:
C16, C17: 100nf; C0402
R17, R18: 10k; R0402
U3, U4: TP181A1-CR

Connections:
+3V3: C16.2, C17.2, R17.2, U3.3 (V+), U4.3 (V+); also elsewhere on the board
CS1: U3.6 (OUT); also elsewhere on the board
CS2: U4.6 (OUT); also elsewhere on the board
GND: C16.1, C17.1, R18.1, U3.2 (GND), U4.2 (GND); also elsewhere on the board
IS1: U3.4 (IN+); also elsewhere on the board
IS2: U4.4 (IN+); also elsewhere on the board
PGND: U3.5 (IN-), U4.5 (IN-); also elsewhere on the board
VREF: R17.1, R18.2, U3.1 (REF), U4.1 (REF)

Notes on the sheet:
3. cirrent_sensor

Notes on the sheet:
5. Readme
