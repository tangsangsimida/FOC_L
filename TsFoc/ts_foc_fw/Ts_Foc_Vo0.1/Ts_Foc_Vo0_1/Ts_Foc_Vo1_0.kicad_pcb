# Repository tangsangsimida/FOC_L (continued)

## KiCad design ts_foc_fw/EG2134_single_motor/EG2134_single_motor_drive/EG2134_single_motor_drive.kicad_pcb (continued)

Parts:
C1: 1uf; C0603
C2, C3, C4, C5: 100nf; C0603
D1, D2, D3, D4, D6, D8: 1N4148W
D5, D7, D9: DSK34
Q1, Q2, Q3, Q4, Q5, Q6: RU3089M-C
R1, R2, R5, R6, R11, R12: 20r; R0402
R3, R10: 10mr; R2512
R4: 0r; R0603
R7, R8, R9: 100r; R0402
U1: EG2134_N; EG2134-N

Connections:
GND: C1.1, C2.1, R4.2, U1.8 (GND); also elsewhere on the board
HO1: D1.1 (K), R1.1, U1.19 (HO1)
HO2: D3.1 (K), R5.1, U1.16 (HO2)
HO3: D6.1 (K), R11.1, U1.13 (HO3)
IN_1: R7.1; also elsewhere on the board
IN_2: R8.1; also elsewhere on the board
IN_3: R9.1; also elsewhere on the board
IS1: Q1.1 (S), Q1.2 (S), Q1.3 (S), R3.1; also elsewhere on the board
IS2: Q3.1 (S), Q3.2 (S), Q3.3 (S), R10.1; also elsewhere on the board
LO1: D2.1 (K), R2.1, U1.11 (LO1)
LO2: D4.1 (K), R6.1, U1.10 (LO2)
LO3: D8.1 (K), R12.1, U1.9 (LO3)
unnamed: D1.2 (A), Q2.4 (G), R1.2
unnamed: D2.2 (A), Q1.4 (G), R2.2
unnamed: D3.2 (A), Q4.4 (G), R5.2
unnamed: D4.2 (A), Q3.4 (G), R6.2
unnamed: D6.2 (A), Q6.4 (G), R11.2
unnamed: D8.2 (A), Q5.4 (G), R12.2
unnamed: R7.2, U1.1 (HIN1), U1.4 (LIN1)
unnamed: R8.2, U1.2 (HIN2), U1.5 (LIN2)
unnamed: R9.2, U1.3 (HIN3), U1.6 (LIN3)
PGND: Q5.1 (S), Q5.2 (S), Q5.3 (S), R3.2, R4.1, R10.2; also elsewhere on the board
U: C3.1, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), Q1.9 (D), Q2.1 (S), Q2.2 (S), Q2.3 (S), U1.18 (VS1); also elsewhere on the board
V: C4.1, Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D), Q3.9 (D), Q4.1 (S), Q4.2 (S), Q4.3 (S), U1.15 (VS2); also elsewhere on the board
VB1: C3.2, D5.1 (K), U1.20 (VB1)
VB2: C4.2, D7.1 (K), U1.17 (VB2)
VB3: C5.2, D9.1 (K), U1.14 (VB3)
VCC: C1.2, C2.2, D5.2 (A), D7.2 (A), D9.2 (A), Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), Q2.9 (D), Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D), Q4.9 (D), Q6.5 (D), Q6.6 (D), Q6.7 (D), Q6.8 (D), Q6.9 (D), U1.7 (VCC); also elsewhere on the board
VS3: C5.1, Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D), Q5.9 (D), Q6.1 (S), Q6.2 (S), Q6.3 (S), U1.12 (VS3); also elsewhere on the board

Notes on the sheet:
2. EG2134

Parts:
CN1: XT30PW-M; XT30PW-M30.G.Y
CN2: WAFER-GH1.25-10PWB
U5: MR30PW-M30.G.Y

Connections:
CS1: CN2.7; also elsewhere on the board
CS2: CN2.6; also elsewhere on the board
GND: CN1.1 (-), CN1.3, CN1.4, CN2.1, CN2.11, CN2.12, U5.4, U5.5; also elsewhere on the board
IN_1: CN2.10; also elsewhere on the board
IN_2: CN2.9; also elsewhere on the board
IN_3: CN2.8; also elsewhere on the board
U: U5.3; also elsewhere on the board
V: U5.2; also elsewhere on the board
VCC: CN1.2 (+); also elsewhere on the board
VS3: U5.1; also elsewhere on the board

Notes on the sheet:
4. Connection

Parts:
C6, C7, C8: 22uf; C0603
C9: 100pf; C0603
C10, C13: 100nf; C0603
C11, C12, C14: 1uf; C0603
C15: 220uf; cap_pol
L1: 6.8uh; FNR6045S6R8MT
LED1: 电源指示灯; NCD0805R1
R13, R16: 10k; R0402
R14: 100k; R0603
R15: 22.1k; R0603
TP1_3V1: 3v3; TestPoint_Pad_D1.5mm
TP2_VCC1: VCC; TestPoint_Pad_D1.5mm
U2: SY8205FCC

Connections:
+3V3: C6.1, C7.1, C8.1, C9.1, L1.1, R13.2, R14.1, TP1_3V1.1; also elsewhere on the board
GND: C6.2, C7.2, C8.2, C11.2, C12.2, C13.1, C14.1, C15.2, LED1.2 (-), R15.2, U2.9 (GND); also elsewhere on the board
unnamed: LED1.1 (+), R13.1
unnamed: C10.2, U2.1 (BS)
unnamed: C10.1, L1.2, U2.2 (LX)
unnamed: C11.1, U2.4 (SS)
unnamed: C12.1, U2.6 (VCC)
VCC: C13.2, C14.2, C15.1, R16.1, TP2_VCC1.1, U2.7 (VIN), U2.8 (VIN); also elsewhere on the board
power_en: R16.2, U2.3 (EN)
power_fb: C9.2, R14.2, R15.1, U2.5 (FB)

Notes on the sheet:
1. Power

Board: 4 copper layers, 61.3 x 22.9 mm, 61 parts (35 on the bottom side), 40 nets.

File ts_foc_fw/EG2134_single_motor/EG2134_single_motor_drive/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C11, C12, C14",C0603,4,1uf,
"C10, C13, C2, C3, C4, C5",C0603,6,100nf,
C15,cap_pol,1,220uf,
"C16, C17",C0402,2,100nf,
"C6, C7, C8",C0603,3,22uf,
C9,C0603,1,100pf,
CN1,XT30PW-M30.G.Y,1,XT30PW-M,
CN2,WAFER-GH1.25-10PWB,1,WAFER-GH1.25-10PWB,
"D1, D2, D3, D4, D6, D8",1N4148W,6,1N4148W,
"D5, D7, D9",DSK34,3,DSK34,
L1,FNR6045S6R8MT,1,6.8uh,
LED1,NCD0805R1,1,电源指示灯,
"Q1, Q2, Q3, Q4, Q5, Q6",RU3089M-C,6,RU3089M-C,
"R1, R11, R12, R2, R5, R6",R0402,6,20r,
"R10, R3",R2512,2,10mr,
"R13, R16, R17, R18",R0402,4,10k,
R14,R0603,1,100k,
R15,R0603,1,22.1k,
R4,R0603,1,0r,
"R7, R8, R9",R0402,3,100r,
U2,SY8205FCC,1,SY8205FCC,
"U3, U4",TP181A1-CR,2,TP181A1-CR,
U5,MR30PW-M30.G.Y,1,MR30PW-M30.G.Y,

## KiCad design ts_foc_fw/EG2134_single_motor/BLDC_driver/BLDC_driver.kicad_pcb

Notes on the sheet:
DC-DC 12/24 -> 5V
EG2134驱动
Cirrent_sensor
readme:
目录：
Connection

Parts:
CN1: XT30PW-M; XT30PW-M30.G.Y
CN2: MR30PW-M30.G.Y
CN3: WAFER-GH1.25-10PWB

Connections:
+12V: CN1.2 (+); also elsewhere on the board
GND: CN1.1 (-), CN1.3, CN1.4, CN2.4, CN2.5, CN3.1, CN3.2, CN3.3, CN3.4, CN3.5, CN3.11, CN3.12; also elsewhere on the board
M0_IN1: CN3.8; also elsewhere on the board
M0_IN2: CN3.7; also elsewhere on the board
M0_IN3: CN3.6; also elsewhere on the board
M0_OUT1_CS: CN3.10; also elsewhere on the board
M0_OUT1_N: CN2.3; also elsewhere on the board
M0_OUT2_CS: CN3.9; also elsewhere on the board
M0_OUT2_N: CN2.2; also elsewhere on the board
M0_OUT3: CN2.1; also elsewhere on the board

Notes on the sheet:
Connection

Notes on the sheet:
1. 原理图:50mil 2. PCB :10mil
栅格尺寸：

Parts:
C10: 1uf; C0603
C11, C12, C13, C14: 100nf; C0603
C15, C16, C17, C18: 10uf; C0805
D2, D3, D4: 1N5819WS
Q1, Q2, Q3, Q4, Q5, Q6: RU3089M-C
R6, R8, R11, R13, R15, R17: 2.2; R0402
R7, R9, R10, R12, R14, R16: 10k; R0402
R20: 0; R0805
U1: EG2134_N; EG2134

Connections:
+5V: D2.2 (A), D3.2 (A), D4.2 (A); also elsewhere on the board
+12V: C15.1, C16.1, C17.1, C18.1, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), Q1.9 (D), Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D), Q3.9 (D), Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D), Q5.9 (D); also elsewhere on the board
GND: C10.1, C11.1, R20.1, U1.8 (GND); also elsewhere on the board
M0_GH1: R6.2, U1.19 (HO1)
M0_GH2: R13.2, U1.16 (HO2)
M0_GH3: R17.2, U1.13 (HO3)
M0_GL1: R8.1, U1.11 (LO1)
M0_GL2: R11.1, U1.10 (LO2)
M0_GL3: R15.1, U1.9 (LO3)
M0_IN1: U1.1 (HIN1), U1.4 (LIN1); also elsewhere on the board
M0_IN2: U1.2 (HIN2), U1.5 (LIN2); also elsewhere on the board
M0_IN3: U1.3 (HIN3), U1.6 (LIN3); also elsewhere on the board
M0_OUT1_P: C12.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), Q2.9 (D), R7.1, U1.18 (VS1); also elsewhere on the board
M0_OUT2_P: C13.1, Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D), Q4.9 (D), R12.1, U1.15 (VS2); also elsewhere on the board
M0_OUT3: C14.1, Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.5 (D), Q6.6 (D), Q6.7 (D), Q6.8 (D), Q6.9 (D), R16.1, U1.12 (VS3); also elsewhere on the board
unnamed: C12.2, D2.1 (K), U1.20 (VB1)
unnamed: C13.2, D3.1 (K), U1.17 (VB2)
unnamed: C14.2, D4.1 (K), U1.14 (VB3)
unnamed: Q1.4 (G), R6.1, R7.2
unnamed: Q2.4 (G), R8.2, R9.1
unnamed: Q3.4 (G), R12.2, R13.1
unnamed: Q4.4 (G), R10.1, R11.2
unnamed: Q5.4 (G), R16.2, R17.1
unnamed: Q6.4 (G), R14.1, R15.2
unnamed: C10.2, C11.2, U1.7 (VCC)
PGND: C15.2, C16.2, C17.2, C18.2, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S), R9.2, R10.2, R14.2, R20.2

Notes on the sheet:
EG2134驱动

Notes on the sheet:
MCU

Parts:
R18, R19: 10mr; R2512
U3, U4: INA240A2PW

Connections:
+3.3V: U3.5 (VS), U3.6 (REF2), U4.5 (VS), U4.6 (REF2); also elsewhere on the board
GND: U3.4 (GND), U3.7 (REF1), U4.4 (GND), U4.7 (REF1); also elsewhere on the board
M0_OUT1_CS: U3.8 (OUT); also elsewhere on the board
M0_OUT1_N: R18.2, U3.2 (IN+); also elsewhere on the board
M0_OUT1_P: R18.1, U3.3 (IN-); also elsewhere on the board
M0_OUT2_CS: U4.8 (OUT); also elsewhere on the board
M0_OUT2_N: R19.2, U4.2 (IN+); also elsewhere on the board
M0_OUT2_P: R19.1, U4.3 (IN-); also elsewhere on the board

Notes on the sheet:
Connection

Parts:
C1, C2, C19, C22: 4.7uf; C0805
C3, C20, C21: 100nf; C0603
C4: 8.2nf; C0603
C5: 1.2nf; C0603
C6: 10pf; C0603
C7: 100nf; C0805
C8, C9: 10uf; C0805
D1: SS34; ss34
L1: SWPA5040S6R8M; SWPA5040S6R8MT
R1: 10k; R0603
R2: 330k; R0603
R3: 68k; R0603
R4: 30k; R0603
R5: 1.87k; R0603
U2: TPS54331DDAR; tps54331
U5: AMS1117-3.3(SOT-89); AMS11173v3-SOT-89

Connections:
+3.3V: C21.2, C22.2, U5.2 (Vout); also elsewhere on the board
+5V: C8.2, C9.2, C19.2, C20.2, L1.2, R1.2, U5.3 (Vin); also elsewhere on the board
+12V: C1.2, C2.2, C3.2, R2.2, U2.2 (VIN); also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.1, C6.1, C8.1, C9.1, C19.1, C20.1, C21.1, C22.1, D1.2 (A), R3.1, R4.1, R5.1, U2.7 (GND), U2.9 (EP), U5.1 (GND); also elsewhere on the board
unnamed: C5.1, R4.2
unnamed: C7.1, D1.1 (K), L1.1, U2.8 (PH)
unnamed: C7.2, U2.1 (BOOT)
unnamed: C5.2, C6.2, U2.6 (COMP)
unnamed: R2.1, R3.2, U2.3 (EN)
unnamed: C4.2, U2.4 (SS)
unnamed: R1.1, R5.2, U2.5 (VSENSE)

Notes on the sheet:
DC-DC 12/24 -> 5V
Power

Board: 2 copper layers, 68.9 x 31.5 mm, 61 parts (15 on the bottom side), 38 nets.

## Code that names these connections

File Tsfoc_Soft_V0_1/TS_FOC_F407/TS_FOC_Demo0_1/TS_FOC_Demo0_1.ioc (part):

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Mcu.Name=STM32F407V(E-G)Tx
Mcu.Package=LQFP100
Mcu.UserName=STM32F407VETx
PA0-WKUP.Signal=ADCx_IN0
PA1.Signal=ADCx_IN1
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.Mode=Device_Only
PA11.Signal=USB_OTG_FS_DM
PA12.Mode=Device_Only
PA12.Signal=USB_OTG_FS_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.Signal=ADCx_IN2
PA3.Signal=ADCx_IN3
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB10.Mode=I2C
PB10.Signal=I2C2_SCL
PB11.Mode=I2C
PB11.Signal=I2C2_SDA
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB5.Mode=CAN_Activate
PB5.Signal=CAN2_RX
PB6.Mode=CAN_Activate
PB6.Signal=CAN2_TX
PB8.Mode=I2C
PB8.Signal=I2C1_SCL
PB9.Mode=I2C
PB9.Signal=I2C1_SDA
PC13-ANTI_TAMP.GPIOParameters=GPIO_Speed,PinState,GPIO_Label,GPIO_ModeDefaultOutputPP
PC13-ANTI_TAMP.GPIO_Label=LED
PC13-ANTI_TAMP.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_PP
PC13-ANTI_TAMP.GPIO_Speed=GPIO_SPEED_FREQ_LOW
PC13-ANTI_TAMP.PinState=GPIO_PIN_SET
PC13-ANTI_TAMP.Signal=GPIO_Output
PC14-OSC32_IN.GPIOParameters=PinState,GPIO_Label
PC14-OSC32_IN.GPIO_Label=Botton
PC14-OSC32_IN.PinState=GPIO_PIN_SET
PC14-OSC32_IN.Signal=GPIO_Output
PC6.Signal=S_TIM8_CH1
PC7.Signal=S_TIM8_CH2
PD0.Mode=CAN_Activate
PD0.Signal=CAN1_RX
PD1.Mode=CAN_Activate
PD1.Signal=CAN1_TX
PD12.Signal=S_TIM4_CH1
PD13.Signal=S_TIM4_CH2
PD14.Signal=S_TIM4_CH3
PD15.Signal=S_TIM4_CH4
PD5.Mode=Asynchronous
PD5.Signal=USART2_TX
PD6.Mode=Asynchronous
PD6.Signal=USART2_RX
PD8.Mode=Asynchronous
PD8.Signal=USART3_TX
PD9.Mode=Asynchronous
PD9.Signal=USART3_RX
PE11.GPIOParameters=GPIO_Label
PE11.GPIO_Label=RGB_G
PE11.Signal=S_TIM1_CH2
PE13.GPIOParameters=GPIO_Label
PE13.GPIO_Label=RGB_B
PE13.Signal=S_TIM1_CH3
PE9.GPIOParameters=GPIO_Label
PE9.GPIO_Label=RGB_R
PE9.Signal=S_TIM1_CH1
PH0-OSC_IN.Mode=HSE-External-Oscillator
PH0-OSC_IN.Signal=RCC_OSC_IN
PH1-OSC_OUT.Mode=HSE-External-Oscillator
PH1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=168000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2024-10-03 第一次同步_FOC算法已经验证并且移植到STM32使用HAL库
2024-10-03 更新readme
2024-10-10 增加本杰明项目源码和cawfoc开发板资料
2024-10-11 永磁双驱
2024-10-16 增加odriver硬件资料
2024-10-20 初始化0_2版本，需要判断是否是角度传感器获取角度太慢了导致速度上来以后旋转变得卡顿，待验证
2024-10-22 同步问题
2024-10-23 规整文件分类
2024-10-31 增加eg2133和eg2134芯片对比文档
2024-11-06 记录编码器硬件问题
2024-11-07 增加kicad硬件版本基于eg2134栅极驱动芯片单个电机电调
2024-11-07 add the cap c0603
2024-11-07 原理图移植完成,PCB还没有布局
2024-11-08 dayly
2024-11-08 PCB_layout_ing
2024-11-08 同步20241108_night
2024-11-09 迭代版本,初版原理图移植有问题,不可使用
2024-11-09 第二版基于EG2134嘉立创开元项目原理图完成
2024-11-13 PCB布局完成，等待布线
2024-11-13 buxian01
2024-11-14 第一版走线完成,准备打板子验证
2024-12-04 tongbu
2024-12-08 2024-12-8同步数据
2024-12-08 重新生成代码前的备份
2024-12-17 F411电压力矩位置环调试完成
2024-12-17 使用串口命令驱动位置闭环和力矩闭环
2024-12-23 同步_2024年 12月 23日 星期一 16:47:35 CST
2024-12-23 同步_2024年 12月 23日 星期一 16:48:38 CST
2024-12-23 同步_2024年 12月 23日 星期一 16:51:04 CST
2024-12-26 同步_2024年 12月 26日 星期四 12:47:49 CST
2025-01-04 同步_2025年 01月 04日 星期六 19:33:09 CST
2025-01-04 同步_2025年 01月 04日 星期六 19:34:21 CST
2025-01-04 同步_2025年 01月 04日 星期六 19:38:04 CST
2025-01-08 同步_2025年 01月 08日 星期三 20:50:40 CST
2025-01-08 同步_2025年 01月 08日 星期三 20:53:07 CST
2025-01-10 同步_2025年 01月 10日 星期五 17:15:53 CST
2025-01-10 同步_2025年 01月 10日 星期五 17:37:28 CST
2025-01-12 同步_2025年 01月 13日 星期一 03:33:41 CST
2025-01-12 同步_2025年 01月 13日 星期一 03:36:46 CST
2025-01-12 更新gitpush脚本_2025年 01月 13日 星期一 03:39:53 CST
2025-01-12 同步_2025年 01月 13日 星期一 03:43:02 CST
2025-01-12 同步_2025年 01月 13日 星期一 03:48:27 CST
2025-01-12 同步_2025年 01月 13日 星期一 03:50:56 CST
2025-01-22 同步_2025年 01月 22日 星期三 19:18:24 CST
2025-01-23 同步_Thu Jan 23 21:05:17 2025
2025-01-24 同步_Fri Jan 24 20:31:29 2025
2025-01-24 重新整理目录分类分组
2025-01-27 vscode尝试同步
2025-01-31 同步_原理图小幅优化
2025-01-31 添加第二批器材采购清单
2025-02-03 添加esc布局板子,备份分离封装库以及符号库,添加主线封装符号库
2025-02-03 PCB_Layout_success
2025-02-03 电源走线完成
2025-02-04 第一版layout完成，准备打板验证
2025-02-04 同步_Tue Feb 4 22:38:42 2025
2025-02-13 同步_Thu Feb 13 10:52:48 2025
2025-02-14 同步_Fri Feb 14 17:11:07 2025
2025-03-26 创建f407程序项目
2025-03-28 cmd线程整理完毕
2025-03-28 同步_Fri Mar 28 13:18:06 2025
2025-04-11 同步_Fri Apr 11 16:16:38 2025
2025-04-14 同步_Mon Apr 14 13:56:21 2025
2025-04-15 del some doc
2025-04-15 同步_Tue Apr 15 15:07:48 2025
2025-04-15 同步_Tue Apr 15 15:08:52 2025
2025-05-01 导入F411TSFOC代码
2025-05-02 移植了get_cmd线程，但是接收不到数据。
2025-05-02 修复get_cmd接收问题
2025-05-03 1. can通信测试通过 2. as5600通信测试通过 3. PCB板桥驱动电路有标签错误，导致有四个引脚未能链接 4.
2025-05-05 嘉立创tsfocvesc201设计完成
2025-05-05 添加oled支持
2025-05-05 1. 整理了所有代码 2. 优化了代码目录 3. 将所有的任务分开了
2025-05-09 同步文件到main分支
2025-05-11 添加tsfoc库 1. 实现简易电压位置闭环控制 2. 实现简易电压力矩闭环控制
2025-05-14 同步_Wed May 14 10:58:01 2025
2025-06-03 同步代码
2025-06-04 汇总论文相关文件
2025-06-07 添加电流采样方案
